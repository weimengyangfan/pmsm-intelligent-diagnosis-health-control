# Keil uVision project STM32F407_SPI_LED_DEMO.uvprojx, settings and files
target F407_SPI_LED_DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(16000000) ELITTLE
  output: f407_spi_led_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: stm32f407zg.sct
  group Application
    ../Core/Src/: main.c board.c fpga_bridge.c led_selftest.c acceptance.c demo.c
  group Startup
    ../Startup/: startup_stm32f407xx.s system_stm32f4xx.c
